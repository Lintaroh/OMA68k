# Repository Lintaroh/OMA68k

## KiCad design circuit/68k8-boad/68k8-boad.kicad_pcb

Parts:
C1: 47u; CP_Radial_D5.0mm_P2.50mm
C2: 100u; CP_Radial_D6.3mm_P2.50mm
C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
D1: D; D_DO-34_SOD68_P7.62mm_Horizontal
D2, D3, D4: LED; LED_D3.0mm
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J2, J3, J4, J5, J6, J7, J8: Conn_02x20_Top_Bottom; PinSocket_2x20_P2.54mm_Vertical
J9: Conn_01x06_Pin; PinHeader_1x06_P2.54mm_Vertical
J10: Conn_01x06_Pin; JST_EH_B6B-EH-A_1x06_P2.50mm_Vertical
J11: Barrel_Jack_Switch; BarrelJack_Horizontal
J12: Conn_01x02_Pin; JST_EH_B2B-EH-A_1x02_P2.50mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R16, R17, R18, R19, R20, R21, R22: 4.7k; R_0603_1608Metric
R8, R9, R10, R11, R12, R13, R14, R15: 33; R_0603_1608Metric
SW1: SW_PUSH_6mm_H5mm
U1: MC68008P; DIP-48_W15.24mm
U2: 27C512; DIP-28_W15.24mm
U3: AS6C4008; DIP-32_W15.24mm
U4: 74HC07; DIP-14_W7.62mm
U5: 74HC161; DIP-16_W7.62mm
U6: 68901; DIP-48_W15.24mm
U7: 74HC04; DIP-14_W7.62mm
U8: 74HC148; DIP-16_W7.62mm
U9, U10, U11: 74HC138; DIP-16_W7.62mm
U12: 74HC32; DIP-14_W7.62mm
U13: 74HC08; DIP-14_W7.62mm
U14: 74HC74; DIP-14_W7.62mm
U15: 74AHC1G14; SOT-23-5
U16: 74HC245; DIP-20_W7.62mm
U17, U18, U19: 74HC541; DIP-20_W7.62mm
Y1: 16MHz; Oscillator_DIP-8

Connections:
+5V: C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, D1.1 (K), D2.2 (A), D3.2 (A), D4.2 (A), J2.37, J2.38, J2.39, J2.40, J4.37, J4.38, J4.39, J4.40, J6.37, J6.38, J6.39, J6.40, J8.37, J8.38, J8.39, J8.40, J10.4, J11.1, J12.1, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R16.1, R17.1, R18.1, R19.1, U1.13 (V_{CC}), U2.28 (VCC), U3.32 (VCC), U4.14 (VCC), U5.1 (~MR), U5.5 (D2), U5.6 (D3), U5.7 (CEP), U5.10 (CET), U5.16 (VCC), U6.11 (VCC), U7.14 (VCC), U8.1 (I4), U8.3 (I6), U8.11 (I1), U8.13 (I3), U8.16 (VCC), U9.6 (E3), U9.16 (VCC), U10.16 (VCC), U11.6 (E3), U11.16 (VCC), U12.14 (VCC), U13.14 (VCC), U14.1 (~R)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
/A0: U1.46 (A0), U2.10 (A0), U3.12 (A0), U17.2 (A0)
/A1: U1.47 (A1), U2.9 (A1), U3.11 (A1), U6.2 (RS1), U11.1 (A0), U17.3 (A1)
/A2: U1.48 (A2), U2.8 (A2), U3.10 (A2), U6.3 (RS2), U11.2 (A1), U17.4 (A2)
/A3: U1.1 (A3), U2.7 (A3), U3.9 (A3), U6.4 (RS3), U11.3 (A2), U17.5 (A3)
/A4: U1.2 (A4), U2.6 (A4), U3.8 (A4), U6.5 (RS4), U17.6 (A4)
/A5: U1.3 (A5), U2.5 (A5), U3.7 (A5), U6.6 (RS5), U17.7 (A5)
/A6: U1.4 (A6), U2.4 (A6), U3.6 (A6), U17.8 (A6)
/A7: U1.5 (A7), U2.3 (A7), U3.5 (A7), U17.9 (A7)
/A8: U1.6 (A8), U2.25 (A8), U3.27 (A8), U18.2 (A0)
/A9: U1.7 (A9), U2.24 (A9), U3.26 (A9), U18.3 (A1)
/A10: U1.8 (A10), U2.21 (A10), U3.23 (A10), U18.4 (A2)
/A11: U1.9 (A11), U2.23 (A11), U3.25 (A11), U18.5 (A3)
/A12: U1.10 (A12), U2.2 (A12), U3.4 (A12), U18.6 (A4)
/A13: U1.11 (A13), U2.26 (A13), U3.28 (A13), U18.7 (A5)
/A14: U1.12 (A14), U2.27 (A14), U3.3 (A14), U18.8 (A6)
/A15: U1.14 (A15), U2.1 (A15), U3.31 (A15), U18.9 (A7)
/A16: U1.16 (A16), U3.2 (A16), U10.1 (A0)
/A17: U1.17 (A17), U3.30 (A17), U10.2 (A1)
/A18: U1.18 (A18), U3.1 (A18), U10.3 (A2)
/A19: U1.19 (A19), U10.6 (E3), U12.1
/CLK: U1.34 (CLK), U5.2 (CP), U6.17 (X1), U6.35 (CLK), U14.9 (Q), U19.8 (A6)
/D0: U1.27 (D0), U2.11 (D0), U3.13 (DQ0), U6.37 (D0), U16.2 (A0)
/D1: U1.26 (D1), U2.12 (D1), U3.14 (DQ1), U6.38 (D1), U16.3 (A1)
/D2: U1.25 (D2), U2.13 (D2), U3.15 (DQ2), U6.39 (D2), U16.4 (A2)
/D3: U1.24 (D3), U2.15 (D3), U3.17 (DQ3), U6.40 (D3), U16.5 (A3)
/D4: U1.23 (D4), U2.16 (D4), U3.18 (DQ4), U6.41 (D4), U16.6 (A4)
/D5: U1.22 (D5), U2.17 (D5), U3.19 (DQ5), U6.42 (D5), U16.7 (A5)
/D6: U1.21 (D6), U2.18 (D6), U3.20 (DQ6), U6.43 (D6), U16.8 (A6)
/D7: U1.20 (D7), U2.19 (D7), U3.21 (DQ7), U6.44 (D7), U16.9 (A7)
/E: U1.38 (E), U19.9 (A7)
/FC0: U1.45 (FC0), U9.1 (A0)
/FC1: U1.44 (FC1), U9.2 (A1)
/FC2: U1.43 (FC2), U9.3 (A2)
/IOI0: J2.13, J4.13, J6.13, J8.13, R8.1
/IOI1: J2.14, J4.14, J6.14, J8.14, R9.1
/IOI2: J2.15, J4.15, J6.15, J8.15, R10.1
/IOI3: J2.16, J4.16, J6.16, J8.16, R11.1
/IOI4: J2.17, J4.17, J6.17, J8.17, R12.1
/IOI5: J2.18, J4.18, J6.18, J8.18, R13.1
/IOI6: J2.19, J4.19, J6.19, J8.19, R14.1
/IOI7: J2.20, J4.20, J6.20, J8.20, R15.1
/R/~W: U1.30 (R/~W), U3.29 (WE#), U6.1 (R/W), U7.5, U19.4 (A2)
/W/~R: U2.22 (~OE), U3.24 (OE#), U7.6, U16.1 (A->B)
/XA0: J1.22, J3.22, J5.22, J7.22, U17.18 (Y0)
/XA1: J1.23, J3.23, J5.23, J7.23, U17.17 (Y1)
/XA2: J1.24, J3.24, J5.24, J7.24, U17.16 (Y2)
/XA3: J1.25, J3.25, J5.25, J7.25, U17.15 (Y3)
/XA4: J1.27, J3.27, J5.27, J7.27, U17.14 (Y4)
/XA5: J1.28, J3.28, J5.28, J7.28, U17.13 (Y5)
/XA6: J1.29, J3.29, J5.29, J7.29, U17.12 (Y6)
/XA7: J1.30, J3.30, J5.30, J7.30, U17.11 (Y7)
/XA8: J1.32, J3.32, J5.32, J7.32, U18.18 (Y0)
/XA9: J1.33, J3.33, J5.33, J7.33, U18.17 (Y1)
/XA10: J1.34, J3.34, J5.34, J7.34, U18.16 (Y2)
/XA11: J1.35, J3.35, J5.35, J7.35, U18.15 (Y3)
/XA12: J1.37, J3.37, J5.37, J7.37, U18.14 (Y4)
/XA13: J1.38, J3.38, J5.38, J7.38, U18.13 (Y5)
/XA14: J1.39, J3.39, J5.39, J7.39, U18.12 (Y6)
/XA15: J1.40, J3.40, J5.40, J7.40, U18.11 (Y7)
/XCLK: J2.10, J4.10, J6.10, J8.10, U19.12 (Y6)
/XD0: J1.2, J3.2, J5.2, J7.2, U16.18 (B0)
/XD1: J1.3, J3.3, J5.3, J7.3, U16.17 (B1)
/XD2: J1.4, J3.4, J5.4, J7.4, U16.16 (B2)
/XD3: J1.5, J3.5, J5.5, J7.5, U16.15 (B3)
/XD4: J1.7, J3.7, J5.7, J7.7, U16.14 (B4)
/XD5: J1.8, J3.8, J5.8, J7.8, U16.13 (B5)
/XD6: J1.9, J3.9, J5.9, J7.9, U16.12 (B6)
/XD7: J1.10, J3.10, J5.10, J7.10, U16.11 (B7)
/XE: J2.28, J4.28, J6.28, J8.28, U19.11 (Y7)
/XR/~W: J2.6, J4.6, J6.6, J8.6, U19.16 (Y2)
/X~AS: J2.3, J4.3, J6.3, J8.3, U19.18 (Y0)
/X~DS: J2.4, J2.5, J4.4, J4.5, J6.4, J6.5, J8.4, J8.5, U19.17 (Y1)
/uart_Rx: J9.3, J10.3, U6.9 (SI)
/uart_Tx: J9.2, J10.2, U6.8 (SO)
/uart_clk: U5.11 (Q3), U6.7 (TC), U6.10 (RC)
/~AS: U1.28 (~AS), U9.5 (E2), U10.5 (E2), U17.1 (G1), U18.1 (G1), U19.2 (A0)
/~DS: U1.29 (~DS), U6.47 (DS), U12.2, U12.9, U16.19 (CE), U19.3 (A1)
/~DTACK: J2.12, J4.12, J6.12, J8.12, R1.2, U1.31 (~DTACK), U4.2, U4.8, U4.10
/~EX0: J2.23, U10.13 (O2)
/~EX1: J4.23, U10.12 (O3)
/~EX2: J6.23, U10.11 (O4)
/~EX3: J8.23, U10.10 (O5)
/~HALT: R6.2, U1.36 (~HALT), U4.6
/~INT5: J2.26, J4.26, J6.26, J8.26, R17.2, U8.2 (I5)
/~INT7: J2.27, J4.27, J6.27, J8.27, R18.2, U8.4 (I7)
/~INTACK2: U6.45 (IACK), U11.13 (O2)
/~INTACK5: J2.24, J4.24, J6.24, J8.24, U11.10 (O5)
/~INTACK7: J2.25, J4.25, J6.25, J8.25, U11.7 (O7)
/~IPL0/2: U1.42 (~IPL2/~IPL0), U8.9 (S0)
/~IPL1: U1.41 (~IPL1), U8.7 (S1)
/~MFP_INT: R16.2, U6.32 (IRQ), U8.12 (I2)
/~MFP: U6.48 (CS), U10.14 (O1)
/~RAM_acces: U3.22 (CE#), U4.9, U12.6
/~RAM_active: U12.5, U14.5 (Q)
/~RESET: J2.11, J4.11, J6.11, J8.11, R7.2, U1.37 (~RESET), U4.4, U6.21 (RESET), U14.4 (~S)
/~ROM_acces: U2.20 (~CE), U12.8
/~ROM_addr: U7.3, U10.15 (O0), U13.9
/~VPA: J2.29, J4.29, J6.29, J8.29, R4.2, U1.39 (~VPA)
/~intack: U9.7 (O7), U11.5 (E2)
/~super_data: U9.10 (O5), U13.4
/~super_pgm: U9.9 (O6), U13.5
/~user_data: U9.14 (O1), U13.1
/~user_pgm: U9.13 (O2), U13.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, J1.1, J1.6, J1.11, J1.16, J1.21, J1.26, J1.31, J1.36, J2.1, J2.2, J2.21, J2.22, J3.1, J3.6, J3.11, J3.16, J3.21, J3.26, J3.31, J3.36, J4.1, J4.2, J4.21, J4.22, J5.1, J5.6, J5.11, J5.16, J5.21, J5.26, J5.31, J5.36, J6.1, J6.2, J6.21, J6.22, J7.1, J7.6, J7.11, J7.16, J7.21, J7.26, J7.31, J7.36, J8.1, J8.2, J8.21, J8.22, J9.6, J10.6, J11.2, J12.2, SW1.2, U1.15 (GND), U1.35 (GND), U2.14 (GND), U3.16 (VSS), U4.7 (GND)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
unnamed: C1.1, D1.2 (A), R19.2, SW1.1, U15.2
unnamed: D2.1 (K), R20.2
unnamed: D3.1 (K), R21.2
unnamed: D4.1 (K), R22.2
unnamed: R20.1, U13.3
unnamed: R21.1, U13.6
unnamed: R22.1, U13.11
unnamed: R5.2, U1.40 (~BERR)
unnamed: R3.2, U1.32 (~BG)
unnamed: R2.2, U1.33 (~BR)
unnamed: U4.3, U7.8
unnamed: U4.5, U7.10
unnamed: U5.15 (TC), U7.1
unnamed: U5.9 (~PE), U7.2
unnamed: U4.11, U6.46 (DTACK)
unnamed: R8.2, U6.22 (I0)
unnamed: R9.2, U6.23 (I1)
unnamed: R10.2, U6.24 (I2)
unnamed: R11.2, U6.25 (I3)
unnamed: R12.2, U6.26 (I4)
unnamed: R13.2, U6.27 (I5)
unnamed: R14.2, U6.28 (I6)
unnamed: R15.2, U6.29 (I7)
unnamed: U12.3, U12.4
unnamed: U4.1, U12.10, U13.8
unnamed: U7.9, U7.11, U13.12, U13.13, U15.4
unnamed: U7.4, U14.3 (C)
unnamed: U13.10, U14.6 (~Q)
unnamed: U14.11 (C), Y1.5 (OUT)
unnamed: U14.8 (~Q), U14.12 (D)

Notes on the sheet:
シリアル通信用クロックの生成

Board: 2 copper layers, 200.0 x 135.0 mm, 85 parts (0 on the bottom side), 135 nets.

## KiCad design circuit/V9938-board/V9938-board.kicad_pcb

Parts:
C1, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C23, C24: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
C2: 470u; CP_Radial_D8.0mm_P3.50mm
C3: 100u; CP_Radial_D6.3mm_P2.50mm
C4: 10u; CP_Radial_D5.0mm_P2.50mm
C19, C20: 10u; C_Disc_D4.7mm_W2.5mm_P5.00mm
C21, C22: 15p; C_0603_1608Metric
J1, J4, J5: RCA; RDJ
J2, J3: Conn_02x20_Top_Bottom; PinHeader_2x20_P2.54mm_Vertical
R1, R2, R3, R4, R11, R12: 4.7k; R_0603_1608Metric
R5: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R6: 75; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R7, R9: 510; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R8, R10: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: V9938; SDIP64
U2: 74LS05; DIP-14_W7.62mm
U3: 74LS32; DIP-14_W7.62mm
U4: NJM2575; SOT-23-6
U5: 74LS138; DIP-16_W7.62mm
U6, U7: SN76489AN; DIP-16_W7.62mm
U8, U9, U10, U11, U12, U13: HM50464; DIP-18_W7.62mm
U14: 74LS02; DIP-14_W7.62mm
U15: MCP602; DIP-8_W7.62mm
Y1: 21.47727M; Crystal_HC49-4H_Vertical

Connections:
+5V: C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C23.1, C24.1, J3.37, J3.38, J3.39, J3.40, R1.1, R2.1, R3.1, R4.1, R5.1, R11.1, R12.1, U1.26 (~LPS), U1.27 (~LPD), U1.58 (V_{CC}), U2.14 (VCC), U3.14 (VCC), U4.6 (V+), U5.6 (E3), U5.16 (VCC), U6.16 (V_{CC}), U7.16 (V_{CC}), U8.9 (V_{CC}), U9.9 (V_{CC}), U10.9 (V_{CC}), U11.9 (V_{CC}), U12.9 (V_{CC}), U13.9 (V_{CC}), U14.14 (VCC), U15.8 (V+)
/3.579545MHz: U1.8 (CPUCLK), U6.14 (CLOCK), U7.14 (CLOCK), U14.12
/AD0: U1.49 (AD0), U8.14 (A0), U9.14 (A0), U10.14 (A0), U11.14 (A0), U12.14 (A0), U13.14 (A0)
/AD1: U1.50 (AD1), U8.13 (A1), U9.13 (A1), U10.13 (A1), U11.13 (A1), U12.13 (A1), U13.13 (A1)
/AD2: U1.51 (AD2), U8.12 (A2), U9.12 (A2), U10.12 (A2), U11.12 (A2), U12.12 (A2), U13.12 (A2)
/AD3: U1.52 (AD3), U8.11 (A3), U9.11 (A3), U10.11 (A3), U11.11 (A3), U12.11 (A3), U13.11 (A3)
/AD4: U1.53 (AD4), U8.8 (A4), U9.8 (A4), U10.8 (A4), U11.8 (A4), U12.8 (A4), U13.8 (A4)
/AD5: U1.54 (AD5), U8.7 (A5), U9.7 (A5), U10.7 (A5), U11.7 (A5), U12.7 (A5), U13.7 (A5)
/AD6: U1.55 (AD6), U8.6 (A6), U9.6 (A6), U10.6 (A6), U11.6 (A6), U12.6 (A6), U13.6 (A6)
/AD7: U1.56 (AD7), U8.10 (A7), U9.10 (A7), U10.10 (A7), U11.10 (A7), U12.10 (A7), U13.10 (A7)
/IOI0: J3.13, R2.2, U1.25 (~INT)
/Left_Audio: U6.7 (AUDIO_OUT), U15.3 (+)
/RD0: U1.41 (RD0), U8.2 (I/O1), U9.2 (I/O1), U10.2 (I/O1)
/RD1: U1.42 (RD1), U8.3 (I/O2), U9.3 (I/O2), U10.3 (I/O2)
/RD2: U1.43 (RD2), U8.15 (I/O3), U9.15 (I/O3), U10.15 (I/O3)
/RD3: U1.44 (RD3), U8.17 (I/O4), U9.17 (I/O4), U10.17 (I/O4)
/RD4: U1.45 (RD4), U11.2 (I/O1), U12.2 (I/O1), U13.2 (I/O1)
/RD5: U1.46 (RD5), U11.3 (I/O2), U12.3 (I/O2), U13.3 (I/O2)
/RD6: U1.47 (RD6), U11.15 (I/O3), U12.15 (I/O3), U13.15 (I/O3)
/RD7: U1.48 (RD7), U11.17 (I/O4), U12.17 (I/O4), U13.17 (I/O4)
/Right_Audio: U7.7 (AUDIO_OUT), U15.5 (+)
/R/~W: U1.57 (R/~W), U8.4 (~WE), U9.4 (~WE), U10.4 (~WE), U11.4 (~WE), U12.4 (~WE), U13.4 (~WE)
/XA1: J2.23, U1.29 (MODE0)
/XA2: J2.24, U1.28 (MODE1)
/XA13: J2.38, U5.1 (A0)
/XA14: J2.39, U5.2 (A1)
/XA15: J2.40, U5.3 (A2)
/XD0: J2.2, U1.40 (CD0), U6.3 (D0), U7.3 (D0)
/XD1: J2.3, U1.39 (CD1), U6.2 (D1), U7.2 (D1)
/XD2: J2.4, U1.38 (CD2), U6.1 (D2), U7.1 (D2)
/XD3: J2.5, U1.37 (CD3), U6.15 (D3), U7.15 (D3)
/XD4: J2.7, U1.36 (CD4), U6.13 (D4), U7.13 (D4)
/XD5: J2.8, U1.35 (CD5), U6.12 (D5), U7.12 (D5)
/XD6: J2.9, U1.34 (CD6), U6.11 (D6), U7.11 (D6)
/XD7: J2.10, U1.32 (CD7), U6.10 (D7), U7.10 (D7)
/XR/~W: J3.6, U2.1, U3.5, U3.10, U3.13, U6.5 (~WE), U7.5 (~WE)
/X~DS: J3.4, J3.5, U5.4 (E1)
/~CAS0: U1.61 (~CAS_0), U8.16 (~CAS), U11.16 (~CAS)
/~CAS1: U1.60 (~CAS_1), U9.16 (~CAS), U12.16 (~CAS)
/~CASX: U1.59 (~CAS_X), U10.16 (~CAS), U13.16 (~CAS)
/~DTACK: J3.12, U2.6, U2.8, U2.10
/~EX0: J3.23, U5.5 (E2)
/~PSG1: U3.8, U6.6 (~CE), U14.6
/~PSG2: U3.11, U7.6 (~CE)
/~RAS: U1.62 (~RAS), U8.5 (~RAS), U9.5 (~RAS), U10.5 (~RAS), U11.5 (~RAS), U12.5 (~RAS), U13.5 (~RAS)
/~RESET: J3.11, U1.9 (~RESET)
/~VDP: U2.3, U3.2, U3.4, U5.15 (O0)
GND: C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C21.2, C22.2, C23.2, C24.2, J1.2 (Ext), J2.1, J2.6, J2.11, J2.16, J2.21, J2.26, J2.31, J2.36, J3.1, J3.2, J3.21, J3.22, J4.2 (Ext), J5.2 (Ext), R6.2, R8.2, R10.2, U1.1 (GND), U1.20 (GND/DAC), U2.7 (GND), U2.13, U3.7 (GND), U4.5 (GND), U5.8 (GND), U6.8 (GND), U7.8 (GND), U8.1 (~OE), U8.18 (GND), U9.1 (~OE), U9.18 (GND), U10.1 (~OE), U10.18 (GND), U11.1 (~OE), U11.18 (GND), U12.1 (~OE), U12.18 (GND), U13.1 (~OE), U13.18 (GND), U14.7 (GND), U15.4 (V-)
unnamed: C19.1, R7.2
unnamed: C20.1, R9.2
unnamed: C2.2, J1.1 (In)
unnamed: C19.2, J4.1 (In), R8.1
unnamed: C20.2, J5.1 (In), R10.1
unnamed: R1.2, U2.2, U3.1
unnamed: R3.2, U2.4, U2.5
unnamed: C1.1, R6.1, U1.21 (VIDEO)
unnamed: C22.1, U1.63 (XTAL1), Y1.1
unnamed: C21.1, U1.64 (XTAL2), Y1.2
unnamed: U1.31 (~CSR), U3.3
unnamed: U1.30 (~CSW), U3.6
unnamed: R4.2, U1.3 (~DLCLK)
unnamed: R5.2, U4.1 (PowerSave)
unnamed: C1.2, U4.4 (V_{IN})
unnamed: C2.1, U4.2 (V_{OUT}), U4.3 (V_{SAG})
unnamed: U3.9, U5.14 (O1)
unnamed: U3.12, U5.13 (O2)
unnamed: R11.2, U6.4 (READY), U14.2, U14.3
unnamed: R12.2, U7.4 (READY), U14.8, U14.9
unnamed: U14.1, U14.5
unnamed: U2.9, U14.4
unnamed: U14.10, U14.11
unnamed: U2.11, U14.13
unnamed: R7.1, U15.1, U15.2 (-)
unnamed: R9.1, U15.6 (-), U15.7

Board: 2 copper layers, 100.0 x 135.0 mm, 57 parts (0 on the bottom side), 74 nets.
